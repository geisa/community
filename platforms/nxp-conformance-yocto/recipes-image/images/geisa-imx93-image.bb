DESCRIPTION = "A production image for geisa-imx93"
require geisa-imx93-common.inc

IMAGE_FEATURES:remove = "debug-tweaks"
