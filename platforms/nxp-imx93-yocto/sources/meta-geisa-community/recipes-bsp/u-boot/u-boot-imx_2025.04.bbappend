# SPDX-License-Identifier: Apache-2.0

SRCREV:geisa-imx93-machine = "${GEISA_UBOOT_SRCREV}"
