PACKAGECONFIG:remove:geisa-container = "sysvinit"
